<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>am_transmit</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>AM_transmit tutorial</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>768e3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>volume</value></param>
<param><key>value</key><value>1.2</value></param>
<param><key>label</key><value>Audio_gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>100e-3</value></param>
<param><key>stop</key><value>10</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>500e-3</value></param>
<param><key>freq</key><value>48e3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/hypersonic/Downloads/around_the_world-atc.wav</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1.2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0</value></param>
<param><key>interp</key><value>16</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>48kHz Carrier</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>4096</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>zeromq_pub_sink</key>
<param><key>id</key><value>zeromq_pub_sink_0</value></param>
<param><key>address</key><value>tcp://127.0.0.1:50001</value></param>
<param><key>type</key><value>float</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>zeromq_pub_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
